# Keil uVision project STM32F030F4 VGA.uvproj, settings and files
target VGA (6210000::V6.21::ARMCLANG)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: VGA +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./: startup_stm32f030.s vga-min.c serial.c fifo.c ps2.c rcc.c term.c ansi.c vgafont.c
